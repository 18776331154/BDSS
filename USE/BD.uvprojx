# Keil uVision project BD.uvprojx, settings and files
target BD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USE;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWARE\LED;..\HAREWARE\ADC;..\HAREWARE\ENCODER;..\HAREWARE\EXTI;..\HAREWARE\KEY;..\HAREWARE\MOTO;..\HAREWARE\OLED;..\HAREWARE\PSTWO;..\HAREWARE\TIMER;..\HAREWARE\STMFLASH;..\HAREWARE\USART3;..\BALANCE\CONTROL;..\BALANCE\DATASCOP_DP;..\BALANCE\SHOW;..\GLOBAL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USE
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../HAREWARE/ADC/: adc.c
    ../HAREWARE/ENCODER/: encoder.c
    ../HAREWARE/EXTI/: exti.c
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/LED/: led.c
    ../HAREWARE/MOTO/: moto.c
    ../HAREWARE/OLED/: oled.c
    ../HAREWARE/PSTWO/: pstwo.c
    ../HAREWARE/STMFLASH/: stmflash.c
    ../HAREWARE/USART3/: usart3.c
  group BALANCE
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/DATASCOP_DP/: DataScop_DP.c
    ../BALANCE/SHOW/: show.c
  group GLOBAL
    ../GLOBAL/: event_queue.c
